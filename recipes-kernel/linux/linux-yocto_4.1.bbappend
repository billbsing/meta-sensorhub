
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"


SRC_URI += "file://udevd-mac-address.patch"


