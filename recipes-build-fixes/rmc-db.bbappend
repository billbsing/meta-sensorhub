# add licens files

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://LICENSE"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3c01b49fed4df1a79843688fa3f7b9d6"



