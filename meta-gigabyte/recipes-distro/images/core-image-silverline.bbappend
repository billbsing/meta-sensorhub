


IMAGE_INSTALL += "rtlwifi"
IMAGE_INSTALL += "rtlbtusb"
IMAGE_INSTALL += "usb-modeswitch"

