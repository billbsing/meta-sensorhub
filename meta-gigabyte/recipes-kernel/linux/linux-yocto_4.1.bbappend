

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://kernel-modules.cfg"

