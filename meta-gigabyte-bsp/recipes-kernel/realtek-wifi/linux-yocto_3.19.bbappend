FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://realtek-wifi.cfg"

