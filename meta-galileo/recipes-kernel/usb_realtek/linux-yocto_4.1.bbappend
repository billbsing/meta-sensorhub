FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://usb_realtek.cfg"
