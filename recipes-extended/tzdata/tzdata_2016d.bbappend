


FILES_${PN} += "${datadir}/zoneinfo/*"


