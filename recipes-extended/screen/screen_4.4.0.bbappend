
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"


SRC_URI += "file://001-fix-for-multijob-build.patch"

