FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://mtd_ram.cfg"
